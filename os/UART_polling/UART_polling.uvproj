# Keil uVision project UART_polling.uvproj, settings and files
target UART_polling RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UART_polling
  c flags: Optim=1
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./src/: startup_LPC17xx.s
  group System Control Code
    ./src/: system_LPC17xx.c
  group Source Code
    ./src/: uart_polling.c main_uart_polling.c
target UART_polling SIM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: UART_polling
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
